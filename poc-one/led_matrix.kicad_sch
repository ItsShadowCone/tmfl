File: poc-one/led_matrix.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: schematic-v2
Connections:
- no-connect marks 0 -> 114
